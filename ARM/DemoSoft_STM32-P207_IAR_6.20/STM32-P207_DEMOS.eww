<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Project\Audio\Audio.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Project\Camera\Camera.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Project\Ethernet\Ethernet.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Project\SDcard\SDcard.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Project\USB\USB_mouse.ewp</path>
  </project>
  <batchBuild/>
</workspace>


