# IAR project Ethernet.ewp, settings and files
configuration Flash (ARM, debug)
  General.OGChipSelectEditMenu: STM32F207xx ST STM32F207xx
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F2XX
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\Libraries\CMSIS\CM3\CoreSupport; ..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F2xx; ..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc; ..\..\Libraries\STM32_ETH_Driver\inc; ..\..\Libraries\STM32_USB-FS-Device_Driver\inc; ..\..\board\; ..\..\modules\; Ethernet\app\; Ethernet\uip\; Ethernet\uip\httpd\; USB\app\; USB\modules\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: ..\..\board\stm32f2xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group board
    ../../board/: iar_stm32f217ze_sk.c
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/startup/iar/: startup_stm32f2xx.s
  group CMSIS
    ./: system_stm32f2xx.c
  group Ethernet
    Ethernet/app/: clock-arch.c ethernet.c uip-conf.h uipopt.h
  group Ethernet/STM32_ETH_Driver
    ../../Libraries/STM32_ETH_Driver/src/: stm32_eth.c
  group Ethernet/uip
    Ethernet/uip/: psock.c timer.c uip.c uip_arp.c
  group Ethernet/uip/httpd
    Ethernet/uip/httpd/: http-strings.c httpd-cgi.c httpd-fs.c httpd.c
  group STM32F2xx_StdPeriph_Driver
    ../../Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
  group User
    ./: main.c stm32f2xx_it.c
