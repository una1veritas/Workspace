# IAR project usbd_dfu.ewp, settings and files
configuration STM322xG-EVAL_USBD-HS (ARM, debug)
  General.OGChipSelectEditMenu: STM32F207ZG ST STM32F207ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F2XX; USE_STM322xG_EVAL; USE_USB_OTG_HS; USE_ULPI_PHY
  ICCARM.CCIncludePath2: ..\; ..\inc; ..\..\..\..\Libraries\CMSIS\Device\ST\STM32F2xx\Include; ..\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc; ..\..\..\..\Libraries\STM32_USB_OTG_Driver\inc; ..\..\..\..\Libraries\STM32_USB_Device_Library\Core\inc; ..\..\..\..\Libraries\STM32_USB_Device_Library\Class\dfu\inc; ..\..\..\..\Utilities\STM32_EVAL; ..\..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\..\Utilities\STM32_EVAL\STM322xG_EVAL
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: usbd_msc.srec
  ILINK.IlinkOutputFile: STM322xG-EVAL_USBD-HS.out
  ILINK.IlinkIcfFile: stm32f2xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM322xG-EVAL_USBD-FS (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F207xx ST STM32F207xx
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F2XX; USE_STM322xG_EVAL; USE_USB_OTG_FS
  OBJCOPY.OOCOutputFile: usbd_dfu.srec
  ILINK.IlinkOutputFile: STM322xG-EVAL_USBD-FS.out
configuration STM3210C-EVAL_USBD-FS (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F107xC ST STM32F107xC
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; USE_STM3210C_EVAL; USE_USB_OTG_FS
  ICCARM.CCIncludePath2: ..\; ..\inc; ..\..\..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include; ..\..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\..\Libraries\STM32_USB_OTG_Driver\inc; ..\..\..\..\Libraries\STM32_USB_Device_Library\Core\inc; ..\..\..\..\Libraries\STM32_USB_Device_Library\Class\dfu\inc; ..\..\..\..\Utilities\STM32_EVAL; ..\..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\..\Utilities\STM32_EVAL\STM3210C_EVAL
  OBJCOPY.OOCOutputFile: usbd_dfu.srec
  ILINK.IlinkOutputFile: STM3210C-EVAL_USBD-FS.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
configuration STM324xG-EVAL_USBD-HS (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F4xxx ST STM32F4xxx
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX; USE_STM324xG_EVAL; USE_USB_OTG_HS; USE_ULPI_PHY
  ICCARM.CCIncludePath2: ..\; ..\inc; ..\..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\..\Libraries\STM32_USB_OTG_Driver\inc; ..\..\..\..\Libraries\STM32_USB_Device_Library\Core\inc; ..\..\..\..\Libraries\STM32_USB_Device_Library\Class\dfu\inc; ..\..\..\..\Utilities\STM32_EVAL; ..\..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\..\Utilities\STM32_EVAL\STM3240_41_G_EVAL
  ILINK.IlinkOutputFile: STM324xG-EVAL_USBD-HS.out
  ILINK.IlinkIcfFile: stm32f4xx_flash.icf
configuration STM324xG-EVAL_USBD-FS (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F4xxx ST STM32F4xxx
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX; USE_STM324xG_EVAL; USE_USB_OTG_FS
  ICCARM.CCIncludePath2: as above
  ILINK.IlinkOutputFile: STM324xG-EVAL_USBD-FS.out
  ILINK.IlinkIcfFile: stm32f4xx_flash.icf
  group App
    ../src/: app.c stm32fxxx_it.c usb_bsp.c usbd_desc.c usbd_usr.c
  group STM32_EVAL
    ../../../../Utilities/STM32_EVAL/Common/: lcd_log.c
  group STM32F10x
    ../../../../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/iar/: startup_stm32f10x_cl.s
    ../src/: system_stm32f10x.c
  group STM32F10x/STM3210C_EVAL
    ../../../../Utilities/STM32_EVAL/STM3210C_EVAL/: stm3210c_eval.c stm3210c_eval_lcd.c
  group STM32F10x/STM32F10x_StdPeriph_Driver
    ../../../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_spi.c
  group STM32F2xx
    ../../../../Libraries/CMSIS/Device/ST/STM32F2xx/Source/Templates/iar/: startup_stm32f2xx.s
    ../src/: system_stm32f2xx.c
  group STM32F2xx/STM322xG_EVAL
    ../../../../Utilities/STM32_EVAL/STM322xG_EVAL/: stm322xg_eval.c stm322xg_eval_lcd.c
  group STM32F2xx/STM32F2xx_StdPeriph_Driver
    ../../../../Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_i2c.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_syscfg.c
  group STM32F4xx
    ../../../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f4xx.s
    ../src/: system_stm32f4xx.c
  group STM32F4xx/STM324xG_EVAL
    ../../../../Utilities/STM32_EVAL/STM3240_41_G_EVAL/: stm324xg_eval.c stm324xg_eval_lcd.c
  group STM32F4xx/STM32F4xx_StdPeriph_Driver
    ../../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_syscfg.c
  group USB Device/Class/DFU
    ../../../../Libraries/STM32_USB_Device_Library/Class/dfu/src/: usbd_dfu_core.c usbd_dfu_mal.c usbd_flash_if.c usbd_mem_if_template.c usbd_otp_if.c
  group USB Device/Library
    ../../../../Libraries/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group USB Drivers
    ../../../../Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
