# Keil uVision project i2c-test.uvproj, settings and files
target Target_flash (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: usart-test
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\STM32Library\CMSIS\Include;..\..\STM32Library\CMSIS\STM32F4xx;..\..\STM32Library\STM32F4xx_StdPeriph_Driver\inc;..\..\STM32Library\armcore;..\..\stm32f4-i2c
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group cmsis
    ../../STM32Library/CMSIS/STM32F4xx/: stm32f4xx.h system_stm32f4xx.c system_stm32f4xx.h
    ../../STM32Library/CMSIS/Include/: arm_common_tables.h arm_math.h core_cm0.h core_cm3.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h
  group StdPeriph
    ../../STM32Library/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_i2c.c
  group Src
    ../: i2c.h main.c i2c.c stm32f4xx_it.c system_stm32f4xx.c stm32f4xx_conf.h
