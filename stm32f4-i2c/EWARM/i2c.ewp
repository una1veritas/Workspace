# IAR project i2c.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\; ..\..\STM32Library\armcore; ..\..\STM32Library\CMSIS\STM32F4xx; ..\..\STM32Library\STM32F4xx_StdPeriph_Driver\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: 5.srec
  ILINK.IlinkOutputFile: cpp.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 1
  group armcore
    ../../STM32Library/armcore/: delay.c delay.h gpio.c gpio.h i2c.c i2c.h systick.c systick.h usart.c usart.h
  group mainsrc
    ../: main.c stm32f4xx_it.c system_stm32f4xx.c
  group stdperiph
    ../../STM32Library/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c
