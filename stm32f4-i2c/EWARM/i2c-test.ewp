# IAR project i2c-test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\; ..\..\STM32Library\STM32F4xx_StdPeriph_Driver\inc; ..\..\STM32Library\CMSIS\STM32F4xx; ..\..\STM32Library\CMSIS\Include; ..\..\STM32Library\armcore
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: i2c-test.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ../: i2c.c i2c.h main.c platform_config.h stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h system_stm32f4xx.c
    ../../STM32Library/CMSIS/STM32F4xx/startup/iar/: startup_stm32f4xx.s
  group armcore
    ../../STM32Library/armcore/: delay.c delay.h gpio.c gpio.h systick.c systick.h usart.c usart.h
  group StdPeriph
    ../../STM32Library/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c
