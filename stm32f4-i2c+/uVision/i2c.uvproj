# Keil uVision project i2c.uvproj, settings and files
target Target flash (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: i2c +hex
  c flags: Optim=3
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\stm32f4-i2c;..\..\STM32Library\STM32F4xx_StdPeriph_Driver\inc;..\..\STM32Library\CMSIS\Include;..\..\STM32Library\CMSIS\STM32F4xx;..\..\STM32Library\armcore
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group
    ./: startup_stm32f4xx.s
    ../: main.c stm32f4xx_it.c system_stm32f4xx.c
  group stdperiph
    ../../STM32Library/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c
  group armcore
    ../../STM32Library/armcore/: delay.c gpio.c i2c.c systick.c usart.c util.c
