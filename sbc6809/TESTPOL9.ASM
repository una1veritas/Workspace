*	ECHOBACK TEST
*	BY POLLING
*
*	ADDRESS
ACIACS	EQU	$8018
ACIADA	EQU	$8019
STACK	EQU	$1FFF
	ORG	$E000
*
*	POWER ON SEQUENCE
START	LDS	#STACK
*
*	ACIA INITIALIZE
*	LDAA	#$03
*	STAA	ACIACS
*	LDAA	#$15
*	STAA	ACIACS
	LDA 	#$03
	STA 	ACIACS
	LDA 	#$15
	STA 	ACIACS
*
*	ECHOBACK TEST
	LDX	#MESG
	JSR	PDATA
LOOP	JSR	INCH
	JSR	OUTCH
	BRA	LOOP
*
*	INPUT CHAR
*INCH	LDAA	ACIACS
INCH	LDA 	ACIACS
	ASRA
	BCC	INCH
*	LDAA	ACIADA
	LDA 	ACIADA
	RTS
*
*	OUTPUT CHAR
*OUTCH	LDAB	ACIACS
OUTCH	LDA 	ACIACS
	ASRB
	ASRB
	BCC	OUTCH
*	STAA	ACIADA
	STA 	ACIADA
	RTS
*
*	OUTPUT STRING
*PDATA	LDAA	0,X
PDATA	LDA 	0,X
	BEQ	EXIT
	JSR	OUTCH
*	INX
	LEAX 	1,X
	BRA	PDATA
EXIT	RTS
*
*	MESSAGE
MESG	FCB	$0D,$0A
	FCC	'ECHOBACK '
	FCC	'TEST'
	FCB	$0D,$0A
	FCB	$00
*
*	VECTOR
UUINT	RTI
	ORG	$FFF8
	FDB	UUINT
	FDB	UUINT
	FDB	UUINT
	FDB	START
	END
