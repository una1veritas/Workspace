<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\IO_Toggle.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\..\..\Keil\STM32_USART_Pol\STM32_USART_Pol.ewp</path>
  </project>
  <batchBuild/>
</workspace>


