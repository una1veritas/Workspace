# IAR project E407_USART.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\; ..\armcore; ..\USART; ..\..\STM32F4xxLib\CMSIS\Device\ST\STM32F4xx\Include; ..\..\STM32F4xxLib\STM32F4xx_StdPeriph_Driver\Inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: E407_USART.hex
  ILINK.IlinkOutputFile: cpp.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: 5.srec
  group (top)
    ../USART/: main.c startup_stm32f4xx.s stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h
    ../../STM32F4xxLib/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../../STM32F4xxLib/STM32F4xx_StdPeriph_Driver/inc/device_support/: system_stm32f4xx.h
  group armcore
    ../armcore/: armcore.h delay.c delay.h gpio_digital.c gpio_digital.h
  group STM32F4xxStdPeriphDriver
    ../../STM32F4xxLib/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c
