*	ECHOBACK TEST
*	BY POLLING
*
*	ADDRESS
ACIACS	EQU	$8018
ACIADA	EQU	$8019
STACK	EQU	$1FFF
	ORG	$E000
*
*	POWER ON SEQUENCE
START	LDS	#STACK
*
*	ACIA INITIALIZE
	LDAA	#$03
	STAA	ACIACS
	LDAA	#$15
	STAA	ACIACS
*
*	ECHOBACK TEST
	LDX	#MESG
	JSR	PDATA
LOOP	JSR	INCH
	JSR	OUTCH
	BRA	LOOP
*
*	INPUT CHAR
INCH	LDAA	ACIACS
	ASRA
	BCC	INCH
	LDAA	ACIADA
	RTS
*
*	OUTPUT CHAR
OUTCH	LDAB	ACIACS
	ASRB
	ASRB
	BCC	OUTCH
	STAA	ACIADA
	RTS
*
*	OUTPUT STRING
PDATA	LDAA	0,X
	BEQ	EXIT
	JSR	OUTCH
	INX
	BRA	PDATA
EXIT	RTS
*
*	MESSAGE
MESG	FCB	$0D,$0A
	FCC	'ECHOBACK '
	FCC	'TEST'
	FCB	$0D,$0A
	FCB	$00
*
*	VECTOR
UUINT	RTI
	ORG	$FFF8
	FDB	UUINT
	FDB	UUINT
	FDB	UUINT
	FDB	START
	END
